# Keil uVision project app.uvproj, settings and files
target OTP_APP (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: app +hex
  AfterMake: .\copy.bat
  AfterMake: ..\link_hex\make.bat
  c flags: Optimize=9
  c include: .\lib;.\user;.\music_decode;.\ui;.\fm_receive;.\usb_device;..\link_hex;.\aux_fun;.\rtc_fun;.\decode_otp;.\voice_time
  asm include: .\lib;.\user;.\music_decode;.\ui;.\fm_receive;.\usb_device;..\link_hex;.\aux_fun;.\rtc_fun;.\voice_time
  group lib
    ./lib/: uart_page.c adc_page.c ap_emi_page.c cpu_page.c dac_amux_page.c iic_page.c io_page.c main_page.c spi_emi_dma_page.c spi_page.c timer_page.c app.LIB
  group user
    ./user/: main.c uart.c filesystem.c device.c isr.a51 fat_memory.c
    ./ui/: key.c resource.c msgfor_hot.c my_IR_key.c
    ./lib/: STARTUP.A51 power.c
  group music_play
    ./lib/: dac_vol.c
    ./ui/: eq.c
    ./music_decode/: mp3mode.c get_musice_file.c id3.c
  group fm_receive
    ./fm_receive/: fm_receive.c fm_receive_api.c KT_AMFMdrv.c RDA_FM_drv.c
  group usb_device
    ./usb_device/: msgfor_usb.c MANUFACTURE.a51
  group display
    ./ui/: disp_if.c lcdsegment.c my_printf.c
  group iic
    ./user/: iic_io.c iic_api.c
  group aun_fun
    ./aux_fun/: aux_fun.c mcu_master.c iic_drv.c blue_tooth.c blue_tooth_uart_drv.c
  group RTC
    ./rtc_fun/: rtc_cpu.c rtc_fun.c rtc_mode.c
  group INFO
    ../link_hex/: info.txt
  group otp_decode
    ./decode_otp/: decode_otp.c music_resource.c
  group voice_time
    ./voice_time/: voice_time.c voicetime_reource.c
